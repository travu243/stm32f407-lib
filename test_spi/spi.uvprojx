# Keil uVision project spi.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Inc;..\Src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group lib
    ../Inc/: stm32f407xx.h stm32f407xx_gpio_driver.h stm32f407xx_i2c_driver.h stm32f407xx_rcc_driver.h stm32f407xx_spi_driver.h stm32f407xx_usart_driver.h
    ../Src/: stm32f407xx_gpio_driver.c stm32f407xx_i2c_driver.c stm32f407xx_rcc_driver.c stm32f407xx_spi_driver.c stm32f407xx_usart_driver.c
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
